<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LED_Bink_Timer_Interrupt.ewp</path>
  </project>
  <batchBuild />
</workspace>
